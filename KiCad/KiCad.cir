* C:\Users\lukas\git\bte5511_kropl2\KiCad\KiCad.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 30.11.2017 18:50:07

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
P101  ? /IO-Ref ? ? /5V GND GND ? Power
P106  ? ? ? GND ? ? ? /10_**_ /9_**_ /8_**_ PWM
P102  ? ? ? ? ? ? ? ? Analog
P107  /7_**_ /6_**_ /5_**_ /4_**_ /3_**_ /2_**_ /1_Tx0_ /0_Rx0_ PWM
P103  ? ? ? ? ? ? ? ? Analog
P108  /14_Tx3_ /15_Rx3_ /16_Tx2_ /17_Rx2_ /18_Tx1_ /19_Rx1_ ? ? Communication
P105  GND GND /52 /53 /50 ? ? ? ? ? ? ? ? ? ? ? ? ? ? ? ? ? /32 /33 /30 /31 /28 /29 /26 /27 /24 /25 /22 /23 /5V /5V Digital
P104  /50 /5V /52 /53 ? GND SPI
J120  /Energieversorgung/24Vin MDm Banana
J121  GND MDm Banana
J122  GND TEST_1P
* Sheet Name: /Energieversorgung/
L11  Net-_L11-Pad1_ Net-_D11-Pad2_ 47µH
R15  Net-_C11-Pad1_ Net-_Q29-Pad2_ 200k
R16  Net-_Q29-Pad2_ GND 11k5
C11  Net-_C11-Pad1_ GND 150µF
C21  Net-_C21-Pad1_ GND 120µF
L21  Net-_D21-Pad1_ Net-_C21-Pad1_ 47µH
U10  Net-_D11-Pad2_ GND Net-_C10-Pad1_ GND Net-_Q29-Pad2_ /Energieversorgung/5Vint Net-_L11-Pad1_ Net-_R11-Pad2_ MC34063
R11  Net-_L11-Pad1_ Net-_R11-Pad2_ 180
R10  Net-_L11-Pad1_ /Energieversorgung/5Vint 0R330
D21  Net-_D21-Pad1_ GND D_Schottky
C10  Net-_C10-Pad1_ GND 430pF
U20  Net-_R20-Pad1_ Net-_D21-Pad1_ Net-_C20-Pad1_ GND Net-_Q28-Pad3_ /24V Net-_R20-Pad1_ Net-_R20-Pad1_ MC34063
R20  Net-_R20-Pad1_ /24V 0R25
C20  Net-_C20-Pad1_ GND 120pF
R25  Net-_Q28-Pad3_ Net-_C21-Pad1_ 200k
R26  GND Net-_Q28-Pad3_ 67k
L12  Net-_C11-Pad1_ /24V 1µH
C12  /24V GND 150µF
L22  Net-_C21-Pad1_ /Energieversorgung/5Vint 1µH
C22  /Energieversorgung/5Vint GND 120µF
L9  /5V /Energieversorgung/5Vint 100µH
Q28  Net-_D28-Pad1_ Net-_C21-Pad1_ Net-_Q28-Pad3_ BSS84
R27  /Energieversorgung/24Vin Net-_D28-Pad1_ 100k
R28  GND Net-_D28-Pad1_ 26k1
D28  Net-_D28-Pad1_ GND D_10V
D11  Net-_C11-Pad1_ Net-_D11-Pad2_ D_Schottky
Q29  Net-_D28-Pad1_ Net-_Q29-Pad2_ /Energieversorgung/5Vint BSS138
D1  /24V /Energieversorgung/24Vin D_Schottky
* Sheet Name: /IO-LinkMaster1/
J301  /24V Net-_C305-Pad2_ GND Net-_C307-Pad1_ ? M12-5
J302  Net-_J302-Pad1_ Net-_J302-Pad2_ GND Conn_01x03
C301  /24V GND 1µF
R301  Net-_C307-Pad1_ Net-_J302-Pad2_ 100k
R303  Net-_C305-Pad2_ Net-_J302-Pad1_ 100k
R302  Net-_J302-Pad2_ GND 16k2
R304  Net-_J302-Pad1_ GND 16k2
U301  /5V /5V Net-_C303-Pad1_ /2_**_ /52 /10_**_ /50 /53 /IO-Ref GND /IO-Ref /1_Tx0_ /6_**_ /0_Rx0_ /9_**_ GND /8_**_ /7_**_ Net-_C305-Pad2_ GND Net-_C307-Pad1_ GND /24V GND GND MAX14824GTG+
C302  /5V GND 220nF
C303  Net-_C303-Pad1_ GND 1µF
C304  /IO-Ref GND 100nF
D301  /24V Net-_C305-Pad2_ D_Schottky
D302  Net-_C305-Pad2_ GND D_Schottky
C305  /24V Net-_C305-Pad2_ 270pF
C306  Net-_C305-Pad2_ GND 270pF
C307  Net-_C307-Pad1_ GND 1nF
D303  /24V /24V GND SM36T1G
D304  GND Net-_C307-Pad1_ ? SM36T1G
J303  /24V Net-_C312-Pad2_ GND Net-_C314-Pad1_ ? M12-5
J304  Net-_J304-Pad1_ Net-_J304-Pad2_ GND Conn_01x03
C308  /24V GND 1µF
R305  Net-_C314-Pad1_ Net-_J304-Pad2_ 100k
R307  Net-_C312-Pad2_ Net-_J304-Pad1_ 100k
R306  Net-_J304-Pad2_ GND 16k2
R308  Net-_J304-Pad1_ GND 16k2
U303  /5V /5V Net-_C310-Pad1_ /4_**_ /52 /10_**_ /50 /53 /IO-Ref GND /IO-Ref /16_Tx2_ /29 /17_Rx2_ /26 GND /27 /28 Net-_C312-Pad2_ GND Net-_C314-Pad1_ /IO-Ref /24V GND GND MAX14824GTG+
C309  /5V GND 220nF
C310  Net-_C310-Pad1_ GND 1µF
C311  /IO-Ref GND 100nF
D305  /24V Net-_C312-Pad2_ D_Schottky
D306  Net-_C312-Pad2_ GND D_Schottky
C312  /24V Net-_C312-Pad2_ 270pF
C313  Net-_C312-Pad2_ GND 270pF
C314  Net-_C314-Pad1_ GND 1nF
D307  /24V /24V GND SM36T1G
D308  GND Net-_C314-Pad1_ ? SM36T1G
J305  /24V Net-_C319-Pad2_ GND Net-_C321-Pad1_ ? M12-5
J306  Net-_J306-Pad1_ Net-_J306-Pad2_ GND Conn_01x03
C315  /24V GND 1µF
R309  Net-_C321-Pad1_ Net-_J306-Pad2_ 100k
R311  Net-_C319-Pad2_ Net-_J306-Pad1_ 100k
R310  Net-_J306-Pad2_ GND 16k2
R312  Net-_J306-Pad1_ GND 16k2
U302  /5V /5V Net-_C317-Pad1_ /3_**_ /52 /10_**_ /50 /53 /IO-Ref GND /IO-Ref /18_Tx1_ /33 /19_Rx1_ /30 GND /31 /32 Net-_C319-Pad2_ GND Net-_C321-Pad1_ GND /24V /IO-Ref GND MAX14824GTG+
C316  /5V GND 220nF
C317  Net-_C317-Pad1_ GND 1µF
C318  /IO-Ref GND 100nF
D309  /24V Net-_C319-Pad2_ D_Schottky
D310  Net-_C319-Pad2_ GND D_Schottky
C319  /24V Net-_C319-Pad2_ 270pF
C320  Net-_C319-Pad2_ GND 270pF
C321  Net-_C321-Pad1_ GND 1nF
D311  /24V /24V GND SM36T1G
D312  GND Net-_C321-Pad1_ ? SM36T1G
J307  /24V Net-_C326-Pad2_ GND Net-_C328-Pad1_ ? M12-5
J308  Net-_J308-Pad1_ Net-_J308-Pad2_ GND Conn_01x03
C322  /24V GND 1µF
R313  Net-_C328-Pad1_ Net-_J308-Pad2_ 100k
R315  Net-_C326-Pad2_ Net-_J308-Pad1_ 100k
R314  Net-_J308-Pad2_ GND 16k2
R316  Net-_J308-Pad1_ GND 16k2
U304  /5V /5V Net-_C324-Pad1_ /5_**_ /52 /10_**_ /50 /53 /IO-Ref GND /IO-Ref /14_Tx3_ /25 /15_Rx3_ /22 GND /23 /24 Net-_C326-Pad2_ GND Net-_C328-Pad1_ /IO-Ref /24V /IO-Ref GND MAX14824GTG+
C323  /5V GND 220nF
C324  Net-_C324-Pad1_ GND 1µF
C325  /IO-Ref GND 100nF
D313  /24V Net-_C326-Pad2_ D_Schottky
D314  Net-_C326-Pad2_ GND D_Schottky
C326  /24V Net-_C326-Pad2_ 270pF
C327  Net-_C326-Pad2_ GND 270pF
C328  Net-_C328-Pad1_ GND 1nF
D315  /24V /24V GND SM36T1G
D316  GND Net-_C328-Pad1_ ? SM36T1G

.end
